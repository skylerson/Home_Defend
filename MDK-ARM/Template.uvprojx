# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MDK-ARM;..\CMSIS;.\Objects;..\Drivers\inc;..\User\Inc;..\Drivers\inc;..\Devices\Oled\Inc;..\UserBsp\Inc;..\UserTask\Inc;..\Algorithm\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\MemMang;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\Devices\my1680u
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers
    ../Drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_hd.s
  group Application/User
    ../User/Src/: main.c sys.c delay.c key.c led.c timer.c usart.c oled.c beep.c user.c
  group Application/UserBsp
    ../UserBsp/Src/: bsp_key.c bsp_sim800a.c
  group Application/UserTask
    ../UserTask/Src/: system_timer_task.c startTask.c userTask.c oledTask.c sim800aTask.c
  group Devices/Oled
    ../Devices/Oled/Src/: bsp_oled.c
  group Algorithm
    ../Algorithm/Src/: filter.c pid.c smath.c cJSON.c
  group Middlewares/freeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
